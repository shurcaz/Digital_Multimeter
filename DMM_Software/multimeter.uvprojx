# Keil uVision project multimeter.uvprojx, settings and files
target Lab Arm Kit (6160000::V6.16::ARMCLANG)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: multimeter
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Main Group
    ./src/: main.c
    ./src/MEASUREMENT_Controller/: MEASUREMENT_Controller.c
    ./src/MEASUREMENT_Controller/ADC_Drivers/: ADC_Drivers.c
    ./src/MEASUREMENT_Controller/CONVERSION_Lib/: CONVERSION_Lib.c
    ./src/BB_BUS_Drivers/: BB_BUS_Drivers.c
    ./src/MULTIMETER_LCD_Drivers/: MULTIMETER_LCD_Drivers.c
    ./src/PB_LCD_Drivers/: PB_LCD_Drivers.c
    ./src/DMM_PWR_Controller/: DMM_PWR_Controller.c
    ./src/MEASUREMENT_Controller/FREQUENCY_Drivers/: FREQUENCY_Drivers.c
software components: CMSIS:CORE 5.5.0, Device:Startup 2.6.3
